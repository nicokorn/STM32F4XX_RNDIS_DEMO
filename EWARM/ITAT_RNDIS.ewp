# IAR project ITAT_RNDIS.ewp, settings and files
configuration ITAT_RNDIS (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CC ST STM32F411CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F411xE
  ICCARM.IExtraOptions: --diag_suppress Pe1644; --diag_suppress Pe177
  ICCARM.CCIncludePath2: ../Core/Inc; ../USB_DEVICE/App; ../USB_DEVICE/Target; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ..\Drivers\CMSIS\Include; ..\Middlewares\Third_Party\RNDIS; ..\Middlewares\Third_Party\FreeRTOS-Plus-TCP\include; ..\Middlewares\Third_Party\FreeRTOS-Plus-TCP\portable\Compiler\IAR; ..\Middlewares\Third_Party\printf-master
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: ITAT_RNDIS.hex
  ILINK.IlinkOutputFile: ITAT_RNDIS.out
  ILINK.IlinkIcfFile: stm32f411xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: dhcpserver.c dnsserver.c freertos.c httpserver.c led.c main.c monitor.c queuex.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c tcpip.c
  group Application/User/Core/inc
    ../Core/Inc/: dhcpserver.h dnsserver.h FreeRTOSConfig.h FreeRTOSIPConfig.h httpserver.h led.h main.h monitor.h queuex.h stm32f4xx_hal_conf.h stm32f4xx_it.h tcpip.h
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c
  group Application/User/USB_DEVICE/App/inc
    ../USB_DEVICE/App/: usb_device.h usbd_desc.h
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_adc.c stm32f4xx_ll_usb.c
  group Drivers/STM32F4xx_HAL_Driver/inc
    ../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal_dma.h stm32f4xx_hal_tim.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/FreeRTOS_TCP
    ../Middlewares/Third_Party/FreeRTOS-Plus-TCP/portable/BufferManagement/: BufferAllocation_2.c
    ../Middlewares/Third_Party/FreeRTOS-Plus-TCP/: FreeRTOS_ARP.c FreeRTOS_DHCP.c FreeRTOS_DNS.c FreeRTOS_IP.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_WIN.c FreeRTOS_UDP_IP.c
    ../Middlewares/Third_Party/FreeRTOS-Plus-TCP/portable/NetworkInterface/HAL_RNDIS_STM32F411/: NetworkInterface.c
  group Middlewares/FreeRTOS_TCP/inc
    ../Middlewares/Third_Party/FreeRTOS-Plus-TCP/include/: FreeRTOS_ARP.h FreeRTOS_DHCP.h FreeRTOS_DNS.h FreeRTOS_errno_TCP.h FreeRTOS_IP.h FreeRTOS_IP_Private.h FreeRTOS_Sockets.h FreeRTOS_Stream_Buffer.h FreeRTOS_TCP_IP.h FreeRTOS_TCP_WIN.h FreeRTOS_UDP_IP.h FreeRTOSIPConfigDefaults.h IPTraceMacroDefaults.h NetworkBufferManagement.h NetworkInterface.h
  group Middlewares/PRINTF
    ../Middlewares/Third_Party/printf-master/: printf.c
  group Middlewares/RNDIS
    ../Middlewares/Third_Party/RNDIS/: usbd_rndis.c
  group Middlewares/RNDIS/inc
    ../Middlewares/Third_Party/RNDIS/: ndis.h rndis_protocol.h usbd_rndis.h
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/USB_Device_Library/Inc
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_ioreq.h
